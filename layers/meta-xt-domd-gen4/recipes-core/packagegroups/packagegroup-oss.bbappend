RDEPENDS:packagegroup-bsp-devpkg:remove = " \
    perf \
"
