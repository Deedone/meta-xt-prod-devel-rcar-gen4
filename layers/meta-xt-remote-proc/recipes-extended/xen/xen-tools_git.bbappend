require xen_common.inc
