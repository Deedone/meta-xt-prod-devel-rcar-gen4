# we expect to have archive with KM near yaml
FILESEXTRAPATHS:prepend := "${TOPDIR}/../..:"
SRC_URI:r8a779g0 = "file://GSX_KM_V4H_DDK23.3_v2.tar.bz2"
